# Keil uVision project project.uvprojx, settings and files
target core0 (6130001::V6.13.1::.\ARMCLANG)
  device: LPC55S69JEV98:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.12.1.1
  cpu: IRAM(0x20000000,0x040000) IRAM2(0x20040000,0x4000) IROM(0x00000000,0x098000) XRAM(0x04000000,0x8000) XRAM2(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: core0 +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\@L.bin"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_LPC55S69JBD100_cm33_core0, ARM_MATH_CM33,MCMGR_HANDLE_EXCEPTIONS=1,  MULTICORE_APP=1,FSL_RTOS_FREE_RTOS,USB_STACK_FREERTOS, USB_STACK_FREERTOS_HEAP_SIZE=16384,
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb -mno-unaligned-access
  c include: .\board;.\Inc;..\freertos\include;..\freertos\portable\GCC\ARM_CM33_NTZ\non_secure;..\cjson;..\drivers;..\mcmgr;..\CMSIS\Include;..\libnfc\include;..\libnfc\libnfc;..\libnfc\libnfc\drivers;..\libnfc\libnfc\chips;..\libnfc\libnfc\buses;..\usb;..\usb\include;..\usb\device;..\osa;..\usb\phy;..\token\inc;..\codec\i2c;..\codec\wm8904;..\codec\port;..\codec
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  asm include: .\core1\Objects
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x4000000 size 0x8000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x4000
  scatter file: .\LPC55S69_cm33_core0_flash.scf
  link misc: ./keil_lib_power_cm33_core0.lib --remove  --keep=*(.m0code) --predefine="-D__stack_size__=0x2000" --predefine="-D__heap_size__=0x100" --predefine="-D__usb_use_usbram__=1"
  group User
    ./Src/: main.c led_app.c adc_app.c battery_app.c ble_wifi_app.c protocol.c flash_app.c cat1_app.c core1_app.c nfc_app.c gpio_input.c
    ./Inc/: main.h
    ./: incbin.S
    ../: token.py
  group Driver
    ./Src/: battery_drv.c adc_drv.c si5351_drv.c w25q128_drv.c soft_iic_drv.c iic_tp100_drv.c
    ../drivers/: fsl_i2s_dma.c
  group Board
    ./board/: clock_config.c clock_config.h peripherals.c peripherals.h pin_mux.c pin_mux.h board.h
  group freertos
    ../freertos/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
    ../freertos/include/: FreeRTOSConfig.h
  group cJson
    ../cjson/: cJSON.c
  group library
    ../drivers/: fsl_clock.c fsl_common.c fsl_ctimer.c fsl_dma.c fsl_flexcomm.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_power.c fsl_spi.c fsl_usart.c fsl_utick.c memory.c fsl_sysctl.c fsl_usart_dma.c fsl_iap.c fsl_rtc.c fsl_pint.c fsl_inputmux.c fsl_reset.c fsl_powerquad_basic.c fsl_powerquad_cmsis.c fsl_powerquad_data.c fsl_powerquad_filter.c fsl_powerquad_math.c fsl_powerquad_transform.c fsl_powerquad_matrix.c generic_list.c fsl_i2s.c fsl_lpadc.c
  group Readme
    ../: readme.txt
  group usb_audio
    ../usb/: audio_unified.c usb_device_descriptor.c composite.c hid_keyboard.c usb_device_config.h
  group usb
    ../usb/phy/: usb_phy.c
    ../usb/: usb_device_hid.c usb_device_audio.c usb_device_class.c usb_device_ch9.c
    ../usb/device/: usb_device_dci.c usb_device_lpcip3511.c
    ../osa/: fsl_os_abstraction_free_rtos.c
  group token
    ../token/src/: base64.c hmac_sha1.c md5.c ota.c
  group codec
    ../codec/: fsl_codec_common.c
    ../codec/wm8904/: fsl_wm8904.c
    ../codec/port/wm8904/: fsl_codec_adapter.c
    ../codec/i2c/: fsl_codec_i2c.c flexcomm_i2c_adapter.c
software components: CMSIS:CORE 5.4.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0
