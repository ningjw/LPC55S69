# Keil uVision project project.uvprojx, settings and files
target core0 (6130001::V6.13.1::.\ARMCLANG)
  device: LPC55S69JEV98:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.12.1.1
  cpu: IRAM(0x20000000,0x040000) IRAM2(0x20040000,0x4000) IROM(0x00000000,0x098000) XRAM(0x04000000,0x8000) XRAM2(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: core0.out
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_LPC55S69JBD100_cm33_core0, ARM_MATH_CM33, MCMGR_HANDLE_EXCEPTIONS=1, __SEMIHOST_HARDFAULT_DISABLE=1, MULTICORE_APP=1, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: .\board;.\Inc
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  asm include: .\core1\Objects
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: ROM 0x4000000 size 0x8000
  memory RVCT7: ROM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x4000
  scatter file: .\LPC55S69_cm33_core0_flash.scf
  group User
    ./Src/: main.c
  group Board
    ./board/: clock_config.c clock_config.h peripherals.c peripherals.h pin_mux.c pin_mux.h
software components: CMSIS:CORE 5.4.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.2.2, Device:SDK Drivers:iap1 2.0.1, Device:SDK Drivers:power 2.0.0, Device:SDK Drivers:reset 2.0.1, Device:Startup 1.0.0
