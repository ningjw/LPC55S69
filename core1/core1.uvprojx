# Keil uVision project core1.uvprojx, settings and files
target core1 (6130001::V6.13.1::.\ARMCLANG)
  device: LPC55S69JBD100:cm33_core1 NXP
  pack: NXP.LPC55S69_DFP.12.1.1
  cpu: CPUTYPE("Cortex-M33")
  output: core1.out
  AfterMake: fromelf.exe --bincombined --bincombined_base=0x20033000 --output=$Lcore1_image.bin !L
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core1, ARM_MATH_CM33, MCMGR_HANDLE_EXCEPTIONS=1, __SEMIHOST_HARDFAULT_DISABLE=1, MULTICORE_APP=1, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..\drivers;.\board;.\;..\mcmgr
  asm define: CPU_LPC55S69JBD100_cm33_core1, DEBUG, KEIL, DEBUG, SLAVEBOOT, NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core1_ram.scf
  link misc: ./keil_lib_power_cm33_core1.lib --remove
  group source
    ./: main.c
  group mcmgr
    ../mcmgr/: mcmgr.c mcmgr_internal_core_api_lpc55s69.c mcmgr.h mcmgr_internal_core_api.h
  group driver
    ../drivers/: fsl_common.c fsl_ctimer.c memory.c fsl_clock.c fsl_iap.c fsl_reset.c
target hello_world_cm33_core1 release (ARM-ADS)
  device: LPC55S69JBD100:cm33_core1 NXP
  pack: NXP.LPC55S69_DFP.12.1.1
  cpu: CPUTYPE("Cortex-M33")
  output: hello_world_cm33_core1.out
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bincombined --bincombined_base=0x20033000 --output=$Lcore1_image.bin !L
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core1, ARM_MATH_CM33, MCMGR_HANDLE_EXCEPTIONS=1, __SEMIHOST_HARDFAULT_DISABLE=1, MULTICORE_APP=1, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: ..;../..;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../middleware/multicore/mcmgr/src;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/drivers;../../../../../../devices/LPC55S69/utilities/str;../../../../../../devices/LPC55S69/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/lists;../../../../../../components/serial_manager;../../../../../../devices/LPC55S69/utilities
  asm define: CPU_LPC55S69JBD100_cm33_core1, NDEBUG, KEIL, NDEBUG, SLAVEBOOT, NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: ROM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core1_ram.scf
  link misc: ../../../../../../devices/LPC55S69/arm/keil_lib_power_cm33_core1.lib --remove
software components: CMSIS:CORE 5.4.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0
