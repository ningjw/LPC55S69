# Keil uVision project project.uvprojx, settings and files
target core1 (6130001::V6.13.1::.\ARMCLANG)
  device: LPC55S69JBD100:cm33_core1 NXP
  pack: NXP.LPC55S69_DFP.12.1.1
  cpu: IRAM(0x20000000,0x040000) IRAM2(0x20040000,0x4000) IROM(0x00000000,0x098000) XRAM(0x04000000,0x8000) XRAM2(0x40100000,0x4000) CPUTYPE("Cortex-M33") CLOCK(12000000) ELITTLE
  output: core1.out
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bincombined --bincombined_base=0x20033000 --output=$Lcore1_image.bin !L
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S69JBD100_cm33_core1, ARM_MATH_CM33, MCMGR_HANDLE_EXCEPTIONS=1, __SEMIHOST_HARDFAULT_DISABLE=1, MULTICORE_APP=1, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: .\board;.\Inc
  asm define: CPU_LPC55S69JBD100_cm33_core1, DEBUG, KEIL, DEBUG, SLAVEBOOT, NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x4000000 size 0x8000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x4000
  scatter file: .\LPC55S69_cm33_core1_ram.scf
  group User
    ./Src/: main.c
  group Board
    ./board/: clock_config.c clock_config.h peripherals.c peripherals.h pin_mux.c pin_mux.h
software components: CMSIS:CORE 5.4.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.2.2, Device:SDK Drivers:ctimer 2.0.3, Device:SDK Drivers:dma 2.4.0, Device:SDK Drivers:flexcomm 2.0.2, Device:SDK Drivers:gpio 2.1.5, Device:SDK Drivers:i2c 2.0.6, Device:SDK Drivers:i2c_dma 2.0.6, Device:SDK Drivers:inputmux 2.0.2, Device:SDK Drivers:inputmux_connections 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpc_rtc 2.1.1, Device:SDK Drivers:mailbox 2.0.0, Device:SDK Drivers:mem_manager 1.0.0, Device:SDK Drivers:power 2.0.0, Device:SDK Drivers:reset 2.0.1, Device:SDK Drivers:spi 2.1.0, Device:SDK Drivers:spi_dma 2.1.0, Device:SDK Drivers:usart 2.1.1, Device:SDK Drivers:usart_adapter 1.0.0, Device:SDK Drivers:usart_dma 2.1.1, Device:SDK Drivers:utick 2.0.3, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.0.0
